# Keil uVision project Template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Core;..\Library\inc;..\User;..\SYSTEM;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c
    ../Core/StartUp/: startup_stm32f10x_md.s
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Hardware
    ../Hardware/RoboModule/: robomodule.c
    ../Hardware/Encoder/: Encoder.c
    ../Hardware/TIM/: timer.c
    ../Hardware/PID/: PID.c
    ../Hardware/KEY/: key.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/LED/: led.c
  group Lib
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Text
    ../: 引脚定义.txt
